# Keil uVision project VibraDistill.uvprojx, settings and files
target VibraDistill_SN32F407 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: SN32F407F SONiX
  pack: SONiX.SN32F4_DFP.1.1.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: VibraDistill +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: .\src;..\VibraDistill_MCU (2);..\..\Documents\Tailieu\antigravity\test;.\src
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\src\SN32F400.sct
  group App
    ./src/: main.c
  group HAL
    ./src/: hal_sn32f407.c
  group CMSIS & Startup
    ./src/: startup_SN32F400.s system_SN32F400.c
